require recipes-security/optee/optee-examples.inc

SRC_URI:remove = "file://0001-Makefile-Fix-non-portable-sh-check-for-plugins.patch"
SRCREV = "f301ee9df2129c0db683e726c91dc2cefe4cdb65"
