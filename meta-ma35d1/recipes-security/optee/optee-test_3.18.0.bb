require recipes-security/optee/optee-test.inc

SRCREV = "da5282a011b40621a2cf7a296c11a35c833ed91b"
